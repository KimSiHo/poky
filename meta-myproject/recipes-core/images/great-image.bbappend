IMAGE_INSTALL += "packagegroup-great"
IMAGE_INSTALL += "openjdk-8 java-mail-app custom-kernel-dev"
IMAGE_INSTALL += "processtestmod datastructuretestmod"
